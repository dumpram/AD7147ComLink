# Keil uVision project AD7147ComLink.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: AD7147ComLink
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\Include;.\StdPeriphDrivers\CMSIS\Include;.\StdPeriphDrivers\CMSIS\Device\ST\STM32F4xx\Include;.\StdPeriphDrivers\STM32F4xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group StartUp
    ./: startup_stm32f40_41xxx.s
    ./StdPeriphDrivers/CMSIS/Device/ST/STM32F4xx/Source/: system_stm32f4xx.c
  group Source
    ./Source/: main.c ad7147.c i2c_conf.c usart.c
  group StdPeriphDrivers
    ./StdPeriphDrivers/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_usart.c
